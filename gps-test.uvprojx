# Keil uVision project gps-test.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gps-test
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\src\testsrc;.\src\configs;.\src;..\..\ccode;..\..\ccode\utility;..\..\ccode\vendor\spl\f1\inc;..\..\ccode\FreeRTOS\Source\include;..\..\ccode\FreeRTOS\Source\portable\RVDS\ARM_CM4F;c:\Keil_v5\ARM\Pack\ARM\CMSIS\5.0.1\CMSIS\Include\
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group sys
    ./src/testsrc/: startup_stm32f10x_md.s
  group src
    ./src/testsrc/: main.cpp
  group testsource
    ./src/nmeautil/: nmea-simu.c clnd.cpp navinote.cpp nmeautil.cpp speedsnaper.cpp nmea-string-reader.h nmea-test-generator.h gps-positioner.cpp
    ../../ccode/utility/etc/: str0.cpp
