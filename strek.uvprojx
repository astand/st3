# Keil uVision project strek.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F401RBTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: strek
  AfterMake: fromelf.exe --bin -o  "objects/bin/st8.bin" "#L"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx STM32F4__ QM66
  c include: .\src;.\src\configs;..\..\ccode;..\..\ccode\utility;..\..\ccode\vendor\spl\f4\inc;..\..\ccode\FreeRTOS\Source\include;..\..\ccode\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\objects\strek3objects\strek.sct
  group sys
    ./src/startup/: startup_stm32f401xx.s system_stm32f4xx.c systick_ll.cpp
  group src
    ./src/: main.cpp generalsett.cpp BoardSide.cpp KillFlash.cpp
  group threads
    ./src/threads/: rtos-init.cpp thread-led.cpp thread-gsm.cpp thread-gps.cpp thread-srv.cpp
  group frtos
    ../../ccode/FreeRTOS/Source/: tasks.c list.c timers.c queue.c event_groups.c
    ../../ccode/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../ccode/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group conf
    ./src/configs/: FreeRTOSConfig.h MainConfig.h version.h dbgconf.h
  group hrdw
    ./src/hdwr/: hw-init.cpp
    ./src/hdwr/controls/: hw-common.cpp hw-adc.cpp hw-gpio.cpp hw-tick-timer.cpp pins-definition.cpp port-init.cpp
    ./src/hdwr/pipes/: hw-spi.cpp hw-gps-serial.cpp hw-gsm-serial.cpp hw-dbg-serial.cpp
  group binlibs
    ../../ccode/vendor/spl/f4/: About.txt SPL-40_41xxx-o2.lib
    ../../ccode/oldcommon/magic/: MagicCM4.lib
  group ccutil
    ../../ccode/utility/timers/: tickerup.cpp timer.cpp d-timer.cpp
    ../../ccode/utility/sys/: Retarget.c
    ../../ccode/utility/buffers/: ringbuffer.cpp
    ../../ccode/utility/streams/: uart-stream.cpp spi-stream.cpp spi-block-sender.cpp
    ../../ccode/utility/bridge/f4/: gpio-hal-f4.cpp
    ../../ccode/utility/etc/: str0.cpp worker.cpp
    ../../ccode/utility/framer/: stuff-framer.cpp
    ../../ccode/utility/framer/crcs/: table0-crc.cpp
  group factory
    ./src/factory/: pipes-maker.cpp switch-maker.cpp McuFlashFactory.cpp modem-maker.cpp bin-maker.cpp services-factory.cpp
  group flshmem
    ../../ccode/oldcommon/McuFlash/FlashMapping/: Mapping.cpp SectorDescriptor.cpp
    ../../ccode/oldcommon/McuFlash/HardwareDriver/: FlashDriver-STM32F4.cpp
    ../../ccode/oldcommon/McuFlash/SaverModel/: MemorySaver.cpp SectorWriter.cpp
  group nmeautil
    ./src/nmeautil/: clnd.cpp navinote.cpp nmeautil.cpp speedsnaper.cpp
  group trekutil
    ./src/trekrep/flash-note-mapper/: mem-notes-mapper.cpp
    ./src/trekrep/: trek-location-descriptor.cpp treksaver.cpp treklist.cpp noteindex.cpp
  group equip
    ../../ccode/equip/flash/: mx-25-driver.cpp
    ../../ccode/equip/gsm/: gsmprot.cpp pdu.cpp at-framer.cpp at-pipe.cpp
    ./src/gsm/: modem.cpp
    ../../ccode/equip/gsm/modems/: m66-fail-detector.cpp
    ../../ccode/equip/pipes/: bin-pipe.cpp
  group rig-protocol
    ./src/rig-tp/common/: bid-control.cpp rig-router.cpp a-read-handler.cpp
    ./src/rig-tp/: track-list-handler.cpp sole-trek-handler.cpp info-handler.cpp
